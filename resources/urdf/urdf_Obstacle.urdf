Commit message: Decalage de l'obstacle

File: resources/urdf/urdf_Obstacle.urdf (robot description, URDF)
Before this commit: robot new Obstacle, 2 links, 1 joints
Joints:
- joint joint_iso_to_obstacle: origin xyz=1 -3 0.10 rpy=0 0 0 -> xyz=1 -10 0.10 rpy=0 0 0
